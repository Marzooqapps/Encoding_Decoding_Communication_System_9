# Keil uVision project Lab9.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab9
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: .;..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: Lab9.c
    ../inc/: startup.s cr4_fft_64_stm32.s cr4_fft_256_stm32.s cr4_fft_1024_stm32.s EdgeInterruptPortF.c
    ../lib/encoder/switches/: switches.c
    ../lib/encoder/tlv5616/: tlv5616.c
    ../lib/decoder/adc/: adc.c
    ../lib/decoder/display/: display.c
    ../lib/decoder/fft/: fft.c
    ../lib/encoder/: encoder.c
